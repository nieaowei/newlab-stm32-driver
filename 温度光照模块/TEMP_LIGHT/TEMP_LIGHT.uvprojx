# Keil uVision project TEMP_LIGHT.uvprojx, settings and files
target TEMP_LIGHT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEMP_LIGHT
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\USER\INC;.\USER\USART;.\USER\SYSTEM;.\USER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group SYSTEM
    ./USER/SYSTEM/: sys.c delay.c fifo.c
  group USER
    ./USER/: main.c
  group TEMP_LIGHT
    ./USER/SRC/: temp_light.c
  group USART
    ./USER/USART/: usart1.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
