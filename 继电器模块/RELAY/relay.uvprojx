# Keil uVision project relay.uvprojx, settings and files
target RELAY (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: relay +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\USER\INC;.\USER\SYSTEM
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Objects\relay.sct
  group USER
    ./USER/: main.c
  group SYSTEM
    ./USER/SYSTEM/: delay.c sys.c fifo.c
  group RELAY
    ./USER/SRC/: relay.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
